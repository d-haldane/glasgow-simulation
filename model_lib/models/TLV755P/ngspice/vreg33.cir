*** auto-generated by jitpcb ***
.title Voltage regulator test circuit
* component TLV755P33
*
.model MOSREG NMOS LEVEL=1 RD=1e-3 RS=1e-3 VTO=-3.3 KP=1000
.model MOSCL NMOS LEVEL=1 RD=1e-3 RS=1e-3 VTO=-75e-3 KP=256
.model MOSEN NMOS LEVEL=1 RD=1e-3 RS=1e-3 VTO=25e-3 KP=1000
V1 VIN 0 EXP(0 5 200u 200u 20 20)
V2 VEN 0 EXP(0 5 200u 200u 20 20)
MSW VIN VEN VSW VSW MOSEN
MCL VSW VCL VCL VCL MOSCL
MREG VCL 0 VOUT VOUT MOSREG
CL VOUT 0 4.7u
RL VOUT 0 50
CCL VCL 0 1n
.options savecurrents filetype=ascii
.save all
.tran 1u 10m 0 10u
.end
