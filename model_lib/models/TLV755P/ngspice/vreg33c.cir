*** auto-generated by jitpcb ***
.title Voltage regulator test circuit
* component TLV755P33
*
.model MOSREG  NMOS LEVEL=1 RD=1e-3 RS=1e-3 VTO=-3.3   KP=1000
.model MOSCL   NMOS LEVEL=1 RD=1e-3 RS=1e-3 VTO=-75e-3 KP=256
.model MOSEN   NMOS LEVEL=1 RD=1e-3 RS=1e-3 VTO=25e-3  KP=1000
.model MOSLOGN NMOS LEVEL=1 RD=10   RS=10   VTO=0.8    KP=1000u
.model MOSLOGP PMOS LEVEL=1 RD=10   RS=10   VTO=-0.3   KP=200u
.model MOSUVLO NMOS LEVEL=1 RD=10   RS=10   VTO=1.3    KP=500u
V1 VIN 0 PWL(0 0 100u 0 200u 5 5m 5 8m 1 10m 5)
V2 VEN 0 PWL(0 0 1m 0 2m 5 5m 5 8m 1.3 10m 5)
I1 VOUT 0 PWL(0 0 11m 0 18m .70)
MSW VIN VGEN VSW VSW MOSEN
MCL VSW VCL VCL VCL MOSCL
MREG VCL 0 VOUT VOUT MOSREG
M4 VNEN VEN VUVLO VUVLO MOSLOGN
M7 VUVLO VIN 0 0 MOSUVLO
M6 VGEN VNEN 0 0 MOSLOGN
M5 VGEN VNEN VIN VIN MOSLOGP
C1 VOUT 0 4.7u
C2 VCL 0 1000p
C3 VNEN 0 100f
C4 VOUT 0 4.7u
C5 VGEN 0 1p
C6 VUVLO 0 100f
C7 VSW 0 100p
R2 VIN VNEN 1MEG
RL VOUT 0 50
CCL VCL 0 1n
.options savecurrents filetype=ascii
.save all
.tran 1u 20m 0 10u
.end
